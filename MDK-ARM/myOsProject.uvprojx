# Keil uVision project myOsProject.uvprojx, settings and files
target myOsProject (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: myOsProject +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,LOG_LEVEL=DBG_LEV_NO
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\App\inc;..\HalInterfaces\inc;..\Test\inc;..\tiny\arch\arm\arm-v7m\common\include;..\tiny\arch\arm\arm-v7m\cortex-m4\armcc;..\tiny\kernel\core\include;..\tiny\kernel\evtdrv\include;..\tiny\kernel\hal\include;..\tiny\kernel\pm\include;..\tiny\osal\cmsis_os;..\tiny\net\at\include;..\tiny\net\sal_module_wrapper;..\tiny\net\socket_wrapper\include;..\tiny\devices\esp8266
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group App
    ../App/src/: applicationEntry.c board.c fly_task_board.c fly_task_net.c
  group HalInterfaces
    ../HalInterfaces/src/: iDebug.c osAbstract.c tinyprintf.c iCharArrayBuffer.c FlyInterUser.s
  group Test
    ../Test/src/: comTest.c TestTask.c
  group tiny/arch
    ../tiny/arch/arm/arm-v7m/cortex-m4/armcc/: port_c.c port_s.S
    ../tiny/arch/arm/arm-v7m/common/: tos_cpu.c tos_fault.c
  group tiny/kernel/core
    ../tiny/kernel/core/: tos_barrier.c tos_binary_heap.c tos_bitmap.c tos_char_fifo.c tos_completion.c tos_countdownlatch.c tos_event.c tos_global.c tos_mail_queue.c tos_message_queue.c tos_mmblk.c tos_mmheap.c tos_mutex.c tos_pend.c tos_priority_mail_queue.c tos_priority_message_queue.c tos_priority_queue.c tos_ring_queue.c tos_robin.c tos_rwlock.c tos_sched.c tos_sem.c tos_stopwatch.c tos_sys.c tos_task.c tos_tick.c tos_time.c tos_timer.c
  group tiny/kernel/evtdrv
    ../tiny/kernel/evtdrv/: tos_evtdrv_event.c tos_evtdrv_global.c tos_evtdrv_msg.c tos_evtdrv_sys.c tos_evtdrv_task.c tos_evtdrv_tick.c tos_evtdrv_timer.c
  group tiny/kernel/hal
    ../tiny/kernel/hal/: tos_hal_uart.c
  group tiny/kernel/pm
    ../tiny/kernel/pm/: tos_pm.c tos_tickless.c
  group tiny/osal
    ../tiny/osal/cmsis_os/: cmsis_os.c
  group tiny/devices
    ../tiny/devices/esp8266/: esp8266.c
  group tiny/net/at
    ../tiny/net/at/src/: tos_at.c
  group tiny/net/sal_module_wrapper
    ../tiny/net/sal_module_wrapper/: sal_module_wrapper.c
  group tiny/net/socket_wrapper
    ../tiny/net/socket_wrapper/: tos_at_socket.c tos_at_socket_lib.c tos_at_socket_prv.c
software components: CMSIS:CORE 4.3.0
